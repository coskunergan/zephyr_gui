# IAR project lvgl_guider.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core0; LV_CONF_INCLUDE_SIMPLE=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa089,Go029,Pe111,Pe236,Pe546,Pa082,Pa050,Pe188,Pe069,Pe550
  ICCARM.CCIncludePath2: ../Core/board; ../Core/source; ../Core/CMSIS; ../Core/component/lists; ../Core/component/uart; ../../custom; ../Core/device; ../Core/drivers; ../Core/freertos/freertos_kernel/include; ../Core/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../generated; ../../generated/guider_customer_fonts; ../../generated/guider_fonts; ../Core/lcd; ../Core/lvgl; ../Core/lvgl/lvgl; ../Core/lvgl/lvgl/src; ../Core/lvgl/lvgl/src/font; ../Core/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../Core/source
  ILINK.IlinkOutputFile: lvgl_guider.out
  ILINK.IlinkIcfFile: MCXN947/iar/MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXN947VDF_cm33_core0; LV_CONF_INCLUDE_SIMPLE=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG
  group board
    ../Core/board/: board.c board.h clock_config.c clock_config.h lvgl_support.c lvgl_support.h pin_mux.c pin_mux.h
  group CMSIS
    ../Core/CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../Core/component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../Core/component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group custom
    ../../custom/: custom.c custom.h custom.mk lv_conf_ext.h pan_procces.c pan_procces.h
  group device
    ../Core/device/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group doc
    ../Core/doc/: readme.txt
  group drivers
    ../Core/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_i3c.c fsl_i3c.h fsl_inputmux.c fsl_inputmux_connections.h fsl_inputmux.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_reset.c fsl_reset.h
  group freertos/freertos_kernel
    ../Core/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../Core/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable
    ../Core/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../Core/freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../Core/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group generated
    ../../generated/: events_init.c events_init.h generated.mk gui_guider.c gui_guider.h setup_scr_logo_screen.c setup_scr_main_screen.c widgets_init.c widgets_init.h
  group generated/guider_customer_fonts
    ../../generated/guider_customer_fonts/: guider_customer_fonts.h guider_customer_fonts.mk
  group generated/guider_fonts
    ../../generated/guider_fonts/: guider_fonts.mk lv_font_Alatsi_Regular_1.c lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c
  group generated/images
    ../../generated/images/: images.mk _empty_800x80.c _img_pan_0_alpha_200x194.c _img_pan_1_alpha_200x194.c _img_pan_2_alpha_200x194.c _img_pan_3_alpha_200x194.c _img_pan_4_alpha_200x194.c _img_pan_5_alpha_200x194.c _img_pan_6_alpha_200x194.c _img_pan_7_alpha_200x194.c _img_pan_8_alpha_200x194.c _img_pan_9_alpha_200x194.c _img_pan_P_alpha_200x194.c _logo_alpha_394x163.c _NoHob_0_alpha_200x194.c _NoHob_1_alpha_200x194.c _NoHob_2_alpha_200x194.c _NoHob_3_alpha_200x194.c _NoHob_4_alpha_200x194.c _NoHob_5_alpha_200x194.c _NoHob_6_alpha_200x194.c _NoHob_7_alpha_200x194.c _NoHob_8_alpha_200x194.c _NoHob_9_alpha_200x194.c _NoHob_P_alpha_200x194.c _Secim_Ver2_alpha_200x194.c _Secim_Ver3_alpha_200x194.c _slider_0_alpha_800x80.c _slider_1_alpha_800x80.c _slider_2_alpha_800x80.c _slider_3_alpha_800x80.c _slider_4_alpha_800x80.c _slider_5_alpha_800x80.c _slider_6_alpha_800x80.c _slider_7_alpha_800x80.c _slider_8_alpha_800x80.c _slider_9_alpha_800x80.c _slider_P_alpha_800x80.c
  group lcd
    ../Core/lcd/: flexio_8080_drv.c flexio_8080_drv.h fsl_ft5406.c fsl_ft5406.h lcd_hx8357_drv.c lcd_hx8357_drv.h
  group MCXN947/iar
    MCXN947/iar/: MCXN947_cm33_core0_flash.icf
  group lvgl
    ../Core/lvgl/: ChangeLogKSDK.txt
  group lvgl/lvgl
    ../Core/lvgl/lvgl/: LICENCE.txt lvgl.h
  group lvgl/lvgl/src
    ../Core/lvgl/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group lvgl/lvgl/src/core
    ../Core/lvgl/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/lvgl/src/draw
    ../Core/lvgl/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_layer.c lv_draw_layer.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_transform.c lv_draw_transform.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/lvgl/src/draw/arm2d
    ../Core/lvgl/lvgl/src/draw/arm2d/: lv_gpu_arm2d.h
  group lvgl/lvgl/src/draw/nxp/pxp
    ../Core/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_blend.c lv_draw_pxp_blend.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
  group lvgl/lvgl/src/draw/nxp/vglite
    ../Core/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite.h lv_draw_vglite_arc.c lv_draw_vglite_arc.h lv_draw_vglite_blend.c lv_draw_vglite_blend.h lv_draw_vglite_line.c lv_draw_vglite_line.h lv_draw_vglite_rect.c lv_draw_vglite_rect.h lv_vglite_buf.c lv_vglite_buf.h lv_vglite_utils.c lv_vglite_utils.h
  group lvgl/lvgl/src/draw/sdl
    ../Core/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_layer.h lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
  group lvgl/lvgl/src/draw/stm32_dma2d
    ../Core/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl/lvgl/src/draw/sw
    ../Core/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/lvgl/src/draw/swm341_dma2d
    ../Core/lvgl/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.h
  group lvgl/lvgl/src/extra
    ../Core/lvgl/lvgl/src/extra/: lv_extra.c lv_extra.h
  group lvgl/lvgl/src/extra/layouts
    ../Core/lvgl/lvgl/src/extra/layouts/: lv_layouts.h
  group lvgl/lvgl/src/extra/layouts/flex
    ../Core/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/lvgl/src/extra/layouts/grid
    ../Core/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/lvgl/src/extra/libs
    ../Core/lvgl/lvgl/src/extra/libs/: lv_libs.h
  group lvgl/lvgl/src/extra/libs/barcode
    ../Core/lvgl/lvgl/src/extra/libs/barcode/: code128.c code128.h lv_barcode.c lv_barcode.h
  group lvgl/lvgl/src/extra/libs/bmp
    ../Core/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/lvgl/src/extra/libs/ffmpeg
    ../Core/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
  group lvgl/lvgl/src/extra/libs/freetype
    ../Core/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
  group lvgl/lvgl/src/extra/libs/fsdrv
    ../Core/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h lv_fs_rawfs.c
  group lvgl/lvgl/src/extra/libs/gif
    ../Core/lvgl/lvgl/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group lvgl/lvgl/src/extra/libs/png
    ../Core/lvgl/lvgl/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
  group lvgl/lvgl/src/extra/libs/qrcode
    ../Core/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
  group lvgl/lvgl/src/extra/libs/rlottie
    ../Core/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
  group lvgl/lvgl/src/extra/libs/sjpg
    ../Core/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
  group lvgl/lvgl/src/extra/others
    ../Core/lvgl/lvgl/src/extra/others/: lv_others.h
  group lvgl/lvgl/src/extra/others/fragment
    ../Core/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c
  group lvgl/lvgl/src/extra/others/gridnav
    ../Core/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/lvgl/src/extra/others/ime
    ../Core/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.h lv_ime_pinyin.c
  group lvgl/lvgl/src/extra/others/imgfont
    ../Core/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c lv_imgfont.h
  group lvgl/lvgl/src/extra/others/monkey
    ../Core/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
  group lvgl/lvgl/src/extra/others/msg
    ../Core/lvgl/lvgl/src/extra/others/msg/: lv_msg.c lv_msg.h
  group lvgl/lvgl/src/extra/others/snapshot
    ../Core/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/lvgl/src/extra/themes
    ../Core/lvgl/lvgl/src/extra/themes/: lv_themes.h
  group lvgl/lvgl/src/extra/themes/basic
    ../Core/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/lvgl/src/extra/themes/default
    ../Core/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/lvgl/src/extra/themes/mono
    ../Core/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/lvgl/src/extra/widgets
    ../Core/lvgl/lvgl/src/extra/widgets/: lv_widgets.h
  group lvgl/lvgl/src/extra/widgets/analogclock
    ../Core/lvgl/lvgl/src/extra/widgets/analogclock/: lv_analogclock.c lv_analogclock.h
  group lvgl/lvgl/src/extra/widgets/animimg
    ../Core/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/lvgl/src/extra/widgets/calendar
    ../Core/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/lvgl/src/extra/widgets/carousel
    ../Core/lvgl/lvgl/src/extra/widgets/carousel/: lv_carousel.c lv_carousel.h
  group lvgl/lvgl/src/extra/widgets/chart
    ../Core/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/lvgl/src/extra/widgets/colorwheel
    ../Core/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/lvgl/src/extra/widgets/dclock
    ../Core/lvgl/lvgl/src/extra/widgets/dclock/: lv_dclock.c lv_dclock.h
  group lvgl/lvgl/src/extra/widgets/imgbtn
    ../Core/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/lvgl/src/extra/widgets/keyboard
    ../Core/lvgl/lvgl/src/extra/widgets/keyboard/: chinese_library.h lv_keyboard.c lv_keyboard.h lv_zh_keyboard.c lv_zh_keyboard.h
  group lvgl/lvgl/src/extra/widgets/led
    ../Core/lvgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
  group lvgl/lvgl/src/extra/widgets/list
    ../Core/lvgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
  group lvgl/lvgl/src/extra/widgets/menu
    ../Core/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.h
  group lvgl/lvgl/src/extra/widgets/meter
    ../Core/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/lvgl/src/extra/widgets/msgbox
    ../Core/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/lvgl/src/extra/widgets/radiobtn
    ../Core/lvgl/lvgl/src/extra/widgets/radiobtn/: lv_radiobtn.c lv_radiobtn.h
  group lvgl/lvgl/src/extra/widgets/span
    ../Core/lvgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
  group lvgl/lvgl/src/extra/widgets/spinbox
    ../Core/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/lvgl/src/extra/widgets/spinner
    ../Core/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/lvgl/src/extra/widgets/tabview
    ../Core/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/lvgl/src/extra/widgets/textprogress
    ../Core/lvgl/lvgl/src/extra/widgets/textprogress/: lv_textprogress.c lv_textprogress.h
  group lvgl/lvgl/src/extra/widgets/tileview
    ../Core/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/lvgl/src/extra/widgets/video
    ../Core/lvgl/lvgl/src/extra/widgets/video/: lv_video.c lv_video.h
  group lvgl/lvgl/src/extra/widgets/win
    ../Core/lvgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
  group lvgl/lvgl/src/font
    ../Core/lvgl/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/lvgl/src/hal
    ../Core/lvgl/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lvgl/src/misc
    ../Core/lvgl/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/lvgl/src/widgets
    ../Core/lvgl/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group source
    ../Core/source/: lv_conf.h lvgl_guider.c FreeRTOSConfig.h
  group startup
    startup/: startup_MCXN947_cm33_core0.s
  group utilities
    ../Core/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
